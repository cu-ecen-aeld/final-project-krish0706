## base_external/package/python-pomodoro/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_POMODORO
	bool "python-pomodoro"
	help
	  This package includes pomodoro server python package.
```
